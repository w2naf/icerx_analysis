<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>channel</value></param>
<param><key>field0</key><value>ch0</value></param>
<param><key>field1</key><value>ch1</value></param>
<param><key>field2</key><value>ch2</value></param>
<param><key>field3</key><value>ch3</value></param>
<param><key>field4</key><value>ch4</value></param>
<param><key>field5</key><value>ch5</value></param>
<param><key>value0</key><value>14095600</value></param>
<param><key>value1</key><value>14670000</value></param>
<param><key>value2</key><value>7038600</value></param>
<param><key>value3</key><value>7850000</value></param>
<param><key>value4</key><value>3568600</value></param>
<param><key>value5</key><value>3330000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>time</value></param>
<param><key>field0</key><value>start</value></param>
<param><key>field1</key><value>stop</value></param>
<param><key>value0</key><value>'2019-01-06T00:00:00Z'</value></param>
<param><key>value1</key><value>'2019-01-07T00:00:00Z'</value></param>
</block>
<block>
<key>gr_digital_rf_digital_rf_source</key>
<param><key>id</key><value>gr_digital_rf_digital_rf_source_0</value></param>
<param><key>channel0</key><value>'{!s}Hz'.format(channel.ch0)</value></param>
<param><key>end0</key><value>time.stop</value></param>
<param><key>start0</key><value>time.start</value></param>
<param><key>channel1</key><value>'{!s}Hz'.format(channel.ch1)</value></param>
<param><key>end1</key><value>time.stop</value></param>
<param><key>start1</key><value>time.start</value></param>
<param><key>channel2</key><value>'{!s}Hz'.format(channel.ch2)</value></param>
<param><key>end2</key><value>time.stop</value></param>
<param><key>start2</key><value>time.start</value></param>
<param><key>channel3</key><value>'{!s}Hz'.format(channel.ch3)</value></param>
<param><key>end3</key><value>time.stop</value></param>
<param><key>start3</key><value>time.start</value></param>
<param><key>channel4</key><value>'{!s}Hz'.format(channel.ch4)</value></param>
<param><key>end4</key><value>time.stop</value></param>
<param><key>start4</key><value>time.start</value></param>
<param><key>channel5</key><value>'{!s}Hz'.format(channel.ch5)</value></param>
<param><key>end5</key><value>time.stop</value></param>
<param><key>start5</key><value>time.start</value></param>
<param><key>top_level_dir</key><value>/home/icerx-vm/ICERX/hf_data</value></param>
<param><key>gapless</key><value>True</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>nchan</key><value>6</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>hide_msg_port</key><value>True</value></param>
<param><key>throttle</key><value>False</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch1</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch2</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_3</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch3</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_4</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch4</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_5</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>channel.ch5</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_3</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_4</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_digital_rf_digital_rf_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_5</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
</flow_graph>
